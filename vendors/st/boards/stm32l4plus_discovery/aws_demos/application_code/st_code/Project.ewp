# IAR project Project.ewp, settings and files
configuration B-L4S5I-IOT01_aws_demos (ARM)
  General.OGChipSelectEditMenu: STM32L4S5VI ST STM32L4S5VI
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: STM32L4S5xx; USE_HAL_DRIVER; SENSOR; __ORDER_LITTLE_ENDIAN__=1; __BYTE_ORDER__=__ORDER_LITTLE_ENDIAN__; MBEDTLS_USER_CONFIG_FILE=<mbedtls_user_config.h>; ENABLE_IMAGE_STATE_HANDLING
  ICCARM.CCIncludePath2: ../../../../../../Drivers/CMSIS/Device/ST/STM32L4xx/Include; ../../../../../../Drivers/STM32L4xx_HAL_Driver/Inc; ../../../../../../Drivers/BSPv2/B-L475E-IOT01; ../Inc; $AFR_DIR$/freertos_kernel/include; $AFR_DIR$/freertos_kernel/portable/IAR/ARM_CM4F; $AFR_DIR$/libraries/abstractions/pkcs11/include; $AFR_DIR$/libraries/abstractions/pkcs11/mbedtls; $AFR_DIR$/libraries/abstractions/platform/include; $AFR_DIR$/libraries/abstractions/platform/freertos/include; $AFR_DIR$/libraries/abstractions/posix/include; $AFR_DIR$/libraries/abstractions/secure_sockets/include; $AFR_DIR$/libraries/abstractions/wifi/include; $AFR_DIR$/libraries/c_sdk/aws/defender/include; $AFR_DIR$/libraries/c_sdk/aws/shadow/include; $AFR_DIR$/libraries/c_sdk/standard/common/include/private; $AFR_DIR$/libraries/c_sdk/standard/common/include; $AFR_DIR$/libraries/c_sdk/standard/https/include; $AFR_DIR$/libraries/c_sdk/standard/mqtt/include; $AFR_DIR$/libraries/c_sdk/standard/serializer/include; $AFR_DIR$/libraries/freertos_plus/aws/greengrass/include; $AFR_DIR$/libraries/freertos_plus/aws/greengrass/src; $AFR_DIR$/libraries/freertos_plus/aws/ota/include; $AFR_DIR$/libraries/freertos_plus/aws/ota/src; $AFR_DIR$/libraries/freertos_plus/standard/crypto/include; $AFR_DIR$/libraries/freertos_plus/standard/freertos_plus_posix/include; $AFR_DIR$/libraries/freertos_plus/standard/pkcs11/include; $AFR_DIR$/libraries/freertos_plus/standard/tls/include; $AFR_DIR$/libraries/freertos_plus/standard/utils/include; $AFR_DIR$/libraries/3rdparty/http_parser; $AFR_DIR$/libraries/3rdparty/jsmn; $AFR_DIR$/libraries/3rdparty/mbedtls/include; $AFR_DIR$/libraries/3rdparty/pkcs11; $AFR_DIR$/libraries/3rdparty/tinycbor; ../../../../../../Middlewares/ST/STM32_Key_Management_Services/tKMS; ../config_files; ../../../../../../Drivers/BSPv2/Components/vl53l0x; ../../../../../../Drivers/CMSIS/Include; ../../../../../../Drivers/CMSIS/Device/ST/stm32l4xx/Include; ../../../../../../Drivers/stm32l4xx_HAL_Driver/Inc; ../../../../../../Drivers/stm32l4xx_HAL_Driver/Inc/Legacy; ../../../../../../Middlewares/ST/STM32_Secure_Engine/Core; $BOOTLOADER_DIR$/2_Images_SBSFU/SBSFU/App; $BOOTLOADER_DIR$/2_Images_SECoreBin/Inc; $BOOTLOADER_DIR$/Linker_Common/EWARM; $AFR_DIR$/demos/dev_mode_key_provisioning/include; $AFR_DIR$/demos/include; $AFR_DIR$/demos/network_manager; ../../../../../../Drivers/BSPv2/Components/es_wifi; ../../../../../../Drivers/BSPv2/Components/vl53l0x
  ICCARM.CCOptLevel: 3
  ICCARM.CCOptStrategy: 1
  ICCARM.IccLang: 0
  AARM.AUserIncludes: $AFR_DIR$/freertos_kernel/include; ../config_files
  OBJCOPY.OOCOutputFile: B-L4S5I-IOT01_aws_demos.bin
  postbuild: cmd /C  "cmd /C $BOOTLOADER_DIR$\2_Images_SECoreBin\EWARM\PostBuild.bat "$PROJ_DIR$" "$TARGET_PATH$" "$TARGET_DIR$\$CONFIG_NAME$.bin" 1 bigelf"
  ILINK.IlinkOutputFile: B-L4S5I-IOT01.out
  ILINK.IlinkIcfFile: stm32l4S5xx_flash_for_sfu.icf
  ILINK.IlinkExtraOptions: --config_search $BOOTLOADER_DIR$\Linker_Common\EWARM\
  ILINK.IlinkAdditionalLibs: $BOOTLOADER_DIR$\2_Images_SBSFU\EWARM\se_interface_appli.o
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group Doc
    ../: readme.txt
  group Application/User
    ../Src/: main.c stm32l4xx_it.c stm32l4xx_hal_timebase_tim.c stm32l4xx_hal_msp.c flash_l4.c es_wifi_io.c watchdogkicker.c
  group Application/AWS/config_files
    ../config_files/: iot_config.h aws_shadow_config.h aws_wifi_config.h aws_secure_sockets_config.h iot_pkcs11_config.h aws_mqtt_config.h aws_ota_agent_config.h iot_mqtt_agent_config.h aws_ggd_config.h aws_iot_network_config.h aws_demo_config.h aws_bufferpool_config.h FreeRTOSConfig.h FreeRTOSIPConfig.h FreeRTOS_POSIX_portable.h mbedtls_user_config.h
  group Application/AWS/ports
    ../Src/ports/: iot_wifi.c iot_secure_sockets.c aws_ota_pal.c iot_pkcs11_st.c
  group Application/EWARM
    ./: startup_stm32l4S5xx.s
  group Middlewares/amazon-freertos/demos
    $AFR_DIR$/demos/include/: aws_clientcredential.h
  group Middlewares/amazon-freertos/demos/defender
    $AFR_DIR$/demos/defender/: aws_iot_demo_defender.c
  group Middlewares/amazon-freertos/demos/demo_runner
    $AFR_DIR$/demos/demo_runner/: aws_demo_version.c aws_demo.c iot_demo_freertos.c iot_demo_runner.c
  group Middlewares/amazon-freertos/demos/dev_mode_key_provisioning
    $AFR_DIR$/demos/dev_mode_key_provisioning/src/: aws_dev_mode_key_provisioning.c
  group Middlewares/amazon-freertos/demos/https
    $AFR_DIR$/demos/https/: iot_demo_https_common.c iot_demo_https_s3_download_async.c iot_demo_https_s3_download_sync.c iot_demo_https_s3_upload_async.c iot_demo_https_s3_upload_sync.c
  group Middlewares/amazon-freertos/demos/mqtt
    $AFR_DIR$/demos/mqtt/: iot_demo_mqtt.c
  group Middlewares/amazon-freertos/demos/network_manager
    $AFR_DIR$/demos/network_manager/: aws_iot_demo_network.c aws_iot_network_manager.c
  group Middlewares/amazon-freertos/demos/ota
    $AFR_DIR$/demos/ota/: aws_iot_ota_update_demo.c
  group Middlewares/amazon-freertos/demos/shadow
    $AFR_DIR$/demos/shadow/: aws_iot_demo_shadow.c
  group Middlewares/amazon-freertos/demos/tcp
    $AFR_DIR$/demos/tcp/: aws_tcp_echo_client_single_task.c
  group Middlewares/amazon-freertos/freertos_kernel
    $AFR_DIR$/freertos_kernel/: event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/amazon-freertos/freertos_kernel/portable
    $AFR_DIR$/freertos_kernel/portable/MemMang/: heap_5.c
    $AFR_DIR$/freertos_kernel/portable/IAR/ARM_CM4F/: port.c portasm.s
  group Middlewares/amazon-freertos/libraries/3rdparty/http_parser
    $AFR_DIR$/libraries/3rdparty/http_parser/: http_parser.c
  group Middlewares/amazon-freertos/libraries/3rdparty/jsmn
    $AFR_DIR$/libraries/3rdparty/jsmn/: jsmn.c
  group Middlewares/amazon-freertos/libraries/3rdparty/mbedtls
    $AFR_DIR$/libraries/3rdparty/mbedtls/library/: aes.c aesni.c arc4.c asn1parse.c asn1write.c base64.c bignum.c blowfish.c camellia.c certs.c cipher.c cipher_wrap.c cmac.c ctr_drbg.c debug.c des.c dhm.c ecdh.c ecdsa.c ecjpake.c ecp.c ecp_curves.c entropy.c entropy_poll.c error.c gcm.c havege.c hmac_drbg.c md.c md2.c md4.c md5.c md_wrap.c memory_buffer_alloc.c net_sockets.c oid.c padlock.c pem.c pk.c pkcs12.c pkcs5.c pkparse.c pkwrite.c pk_wrap.c platform.c platform_util.c ripemd160.c rsa.c rsa_internal.c sha1.c sha256.c sha512.c ssl_cache.c ssl_ciphersuites.c ssl_cli.c ssl_cookie.c ssl_srv.c ssl_ticket.c ssl_tls.c threading.c timing.c version.c version_features.c x509.c x509write_crt.c x509write_csr.c x509_create.c x509_crl.c x509_crt.c x509_csr.c xtea.c
    $AFR_DIR$/libraries/3rdparty/mbedtls/utils/: mbedtls_utils.c
  group Middlewares/amazon-freertos/libraries/3rdparty/tinycbor
    $AFR_DIR$/libraries/3rdparty/tinycbor/: cborencoder.c cborencoder_close_container_checked.c cborerrorstrings.c cborparser.c cborparser_dup_string.c cborpretty.c
  group Middlewares/amazon-freertos/libraries/abstractions/platform
    $AFR_DIR$/libraries/abstractions/platform/freertos/: iot_clock_freertos.c iot_metrics.c iot_network_freertos.c iot_threads_freertos.c
  group Middlewares/amazon-freertos/libraries/c_sdk/aws/defender
    $AFR_DIR$/libraries/c_sdk/aws/defender/src/: aws_iot_defender_api.c aws_iot_defender_collector.c aws_iot_defender_mqtt.c aws_iot_defender_v1.c
  group Middlewares/amazon-freertos/libraries/c_sdk/aws/shadow
    $AFR_DIR$/libraries/c_sdk/aws/shadow/src/: aws_iot_shadow_api.c aws_iot_shadow_operation.c aws_iot_shadow_parser.c aws_iot_shadow_static_memory.c aws_iot_shadow_subscription.c aws_shadow.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/common
    $AFR_DIR$/libraries/c_sdk/standard/common/: iot_device_metrics.c iot_init.c iot_static_memory_common.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/common/logging
    $AFR_DIR$/libraries/c_sdk/standard/common/logging/: iot_logging_task_dynamic_buffers.c iot_logging.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/common/taskpool
    $AFR_DIR$/libraries/c_sdk/standard/common/taskpool/: iot_taskpool.c iot_taskpool_static_memory.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/https
    $AFR_DIR$/libraries/c_sdk/standard/https/src/: iot_https_client.c iot_https_utils.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/mqtt
    $AFR_DIR$/libraries/c_sdk/standard/mqtt/src/: iot_mqtt_agent.c iot_mqtt_api.c iot_mqtt_network.c iot_mqtt_operation.c iot_mqtt_serialize.c iot_mqtt_static_memory.c iot_mqtt_subscription.c iot_mqtt_validate.c
  group Middlewares/amazon-freertos/libraries/c_sdk/standard/serializer
    $AFR_DIR$/libraries/c_sdk/standard/serializer/src/cbor/: iot_serializer_tinycbor_decoder.c iot_serializer_tinycbor_encoder.c
    $AFR_DIR$/libraries/c_sdk/standard/serializer/src/: iot_json_utils.c iot_serializer_static_memory.c
    $AFR_DIR$/libraries/c_sdk/standard/serializer/src/json/: iot_serializer_json_decoder.c iot_serializer_json_encoder.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/aws/greengrass
    $AFR_DIR$/libraries/freertos_plus/aws/greengrass/src/: aws_greengrass_discovery.c aws_helper_secure_connect.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/aws/ota
    $AFR_DIR$/libraries/freertos_plus/aws/ota/src/: aws_iot_ota_agent.c aws_iot_ota_interface.c
    $AFR_DIR$/libraries/freertos_plus/aws/ota/src/http/: aws_iot_ota_http.c
    $AFR_DIR$/libraries/freertos_plus/aws/ota/src/mqtt/: aws_iot_ota_mqtt.c aws_iot_ota_cbor.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/standard/crypto
    $AFR_DIR$/libraries/freertos_plus/standard/crypto/src/: iot_crypto.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/standard/freertos_plus_posix
    $AFR_DIR$/libraries/freertos_plus/standard/freertos_plus_posix/source/: FreeRTOS_POSIX_clock.c FreeRTOS_POSIX_mqueue.c FreeRTOS_POSIX_pthread.c FreeRTOS_POSIX_pthread_barrier.c FreeRTOS_POSIX_pthread_cond.c FreeRTOS_POSIX_pthread_mutex.c FreeRTOS_POSIX_sched.c FreeRTOS_POSIX_semaphore.c FreeRTOS_POSIX_timer.c FreeRTOS_POSIX_unistd.c FreeRTOS_POSIX_utils.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/standard/pkcs11
    $AFR_DIR$/libraries/freertos_plus/standard/pkcs11/src/: iot_pkcs11.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/standard/tls
    $AFR_DIR$/libraries/freertos_plus/standard/tls/src/: iot_tls.c
  group Middlewares/amazon-freertos/libraries/freertos_plus/standard/utils
    $AFR_DIR$/libraries/freertos_plus/standard/utils/src/: iot_pki_utils.c iot_system_init.c
  group Drivers/STM32L4xx_HAL_Driver
    ../../../../../../Drivers/STM32L4xx_HAL_Driver/Src/: stm32l4xx_hal.c stm32l4xx_hal_cortex.c stm32l4xx_hal_crc.c stm32l4xx_hal_crc_ex.c stm32l4xx_hal_cryp.c stm32l4xx_hal_cryp_ex.c stm32l4xx_hal_dac.c stm32l4xx_hal_dac_ex.c stm32l4xx_hal_dfsdm.c stm32l4xx_hal_dfsdm_ex.c stm32l4xx_hal_dma.c stm32l4xx_hal_dma_ex.c stm32l4xx_hal_exti.c stm32l4xx_hal_flash.c stm32l4xx_hal_flash_ex.c stm32l4xx_hal_gpio.c stm32l4xx_hal_hash.c stm32l4xx_hal_hash_ex.c stm32l4xx_hal_i2c.c stm32l4xx_hal_i2c_ex.c stm32l4xx_hal_iwdg.c stm32l4xx_hal_lptim.c stm32l4xx_hal_nand.c stm32l4xx_hal_nor.c stm32l4xx_hal_pwr.c stm32l4xx_hal_pwr_ex.c stm32l4xx_hal_qspi.c stm32l4xx_hal_rcc.c stm32l4xx_hal_rcc_ex.c stm32l4xx_hal_rng.c stm32l4xx_hal_rng_ex.c stm32l4xx_hal_rtc.c stm32l4xx_hal_rtc_ex.c stm32l4xx_hal_spi.c stm32l4xx_hal_spi_ex.c stm32l4xx_hal_sram.c stm32l4xx_hal_tim.c stm32l4xx_hal_tim_ex.c stm32l4xx_hal_uart.c stm32l4xx_hal_uart_ex.c stm32l4xx_hal_usart.c stm32l4xx_hal_usart_ex.c stm32l4xx_hal_wwdg.c stm32l4xx_ll_fmc.c
  group Drivers/CMSIS
    ../Src/: system_stm32l4xx.c
  group Drivers/BSP/Components/es_wifi
    ../../../../../../Drivers/BSPv2/Components/es_wifi/: es_wifi.c
  group BootLoader_STSAFE
    ../: bootloader_readme.txt
